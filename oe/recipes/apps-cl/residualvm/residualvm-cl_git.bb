require residualvm-cl.inc

S = "${WORKDIR}/git"

SRCREV = "5bc9c58902ad03bc2836e8291f01fc25b06044a4"
SRC_URI = "git://github.com/residualvm/residualvm.git;protocol=git;branch=master"
