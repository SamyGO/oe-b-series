require residualvm-cl.inc

S = "${WORKDIR}/git"

SRCREV = "800e968270a4d74150d541e4fdd6e2b441a2772e"
SRC_URI = "git://github.com/residualvm/residualvm.git;protocol=git;branch=branch-0-1-0"
