require scummvm-cl.inc

S = "${WORKDIR}/scummvm-${PV}"

SRC_URI[md5sum] = "9997ea39665cb358c71a6ae4e0a170dc"
SRC_URI[sha256sum] = "01ec715e2972b3aedc23e141643acdcff44d0e56638c0df44d931a84fe7e7f38"
