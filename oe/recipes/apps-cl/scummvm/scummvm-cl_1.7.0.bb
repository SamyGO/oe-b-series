require scummvm-cl.inc

S = "${WORKDIR}/scummvm-${PV}"

SRC_URI[md5sum] = "be91bf3fa2f1b44a82c92cfe8c5cc1c8"
SRC_URI[sha256sum] = "d9ff0e8cf911afa466d5456d28fef692a17d47ddecfd428bf2fef591237c2e66"
