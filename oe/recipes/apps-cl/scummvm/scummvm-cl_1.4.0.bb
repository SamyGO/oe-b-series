require scummvm-cl.inc

S = "${WORKDIR}/scummvm-${PV}"

SRC_URI[md5sum] = "361000b78ebf0d0f449e98238d677be1"
SRC_URI[sha256sum] = "494b12e90749aaa76304aa066c90eede8a5b4a8417900be9702a3e6ab484743d"
