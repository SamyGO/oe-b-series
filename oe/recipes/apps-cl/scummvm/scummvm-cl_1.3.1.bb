require scummvm-cl.inc

S = "${WORKDIR}/scummvm-${PV}"

SRC_URI[md5sum] = "87e5076e93bfa762f1c5d7f45b41d4e2"
SRC_URI[sha256sum] = "b25dc7f7e26ed6df3d901043efb2337a525df4dd3cd1589e772733cfa90037f6"
