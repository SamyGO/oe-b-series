require scummvm-cl.inc

S = "${WORKDIR}/scummvm-${PV}"

FILESPATHPKG_prepend = "scummvm-${PV}:"

SRC_URI[md5sum] = "79f8c12fa7a82f2b9331ef3969f07819"
SRC_URI[sha256sum] = "c5616fec60bd4004006ecbd1f79878edc9f1e6040ca6afc0461ed832505c4b50"
