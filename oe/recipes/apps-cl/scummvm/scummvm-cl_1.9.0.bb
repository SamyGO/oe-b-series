require scummvm-cl.inc

S = "${WORKDIR}/scummvm-${PV}"

SRC_URI[md5sum] = "35f7464c6179e05468a1e1d97886fb07"
SRC_URI[sha256sum] = "813d7d8a76e3d05b45001d37451368711dadc32899ecf907df1cc7abfb1754d2"
