require scummvm-cl.inc

S = "${WORKDIR}/scummvm-${PV}"

SRC_URI[md5sum] = "473c151ff44e3db7b603ecacd800a0d2"
SRC_URI[sha256sum] = "396060da6a8f391438055c292a280048d29dc408c5b615db43256a86f0e57ec4"
