require scummvm-cl.inc

SRCREV = "cb990e68a170f354a7e3"
SRC_URI = "git://github.com/scummvm/scummvm.git;protocol=git;branch=master"

S = "${WORKDIR}/git"
