require scummvm-cl.inc

S = "${WORKDIR}/scummvm-${PV}"

SRC_URI[md5sum] = "b54142a153e0cbbffdb075a5658e0f05"
SRC_URI[sha256sum] = "5230bf512628157be0590f19916d8a9d860c222f04d82519c7d7a5f4fa4f5293"
