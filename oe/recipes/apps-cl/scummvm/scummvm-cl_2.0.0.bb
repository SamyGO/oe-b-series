require scummvm-cl.inc

S = "${WORKDIR}/scummvm-${PV}"

SRC_URI[md5sum] = "8bf3df3364a32d6d0f5f4ef292b8a966"
SRC_URI[sha256sum] = "46482e9f4eccd8590a86c70b024bdd0b319af8cbe8b7abaef592a9c52abbe1dc"
