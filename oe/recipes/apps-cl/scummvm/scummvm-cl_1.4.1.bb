require scummvm-cl.inc

S = "${WORKDIR}/scummvm-${PV}"

SRC_URI[md5sum] = "aa094c2224aad22d5340a1d2d919c883"
SRC_URI[sha256sum] = "fa0a7f0d59524611be0c5b9be9ac7f8e7a72bab1826732e056f88332aa3139da"
