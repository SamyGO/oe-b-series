require scummvm-cl.inc

S = "${WORKDIR}/scummvm-${PV}"

SRC_URI[md5sum] = "d71d1df5c8262556fedbe885972fbf6e"
SRC_URI[sha256sum] = "81831cd878a8daad2976f65c92139a2102233082c7d2770579d7e425b19cea2e"
