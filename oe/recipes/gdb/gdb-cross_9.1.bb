require gdb-cross.inc

PR = "${INC_PR}.0"

S = "${WORKDIR}/${BPN}-${PV}"
