PV="2.6.18.8"

require linux-ssdtv_2.6.18.8.inc

require multi-kernel.inc
